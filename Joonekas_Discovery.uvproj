# Keil uVision project Joonekas_Discovery.uvproj, settings and files
target STM32F4_VCP (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Joonekas_Discovery +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, USE_STM32F4_DISCOVERY, USE_USB_OTG_FS,STM32F4XX,__USE_C99_MATH
  c misc: --fpu=softvfp
  c include: .\inc;.\Libraries\CMSIS\Include;.\Libraries\Device\STM32F4xx\Include;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Libraries\STM32_USB_Device_Library\Class\cdc\inc;.\Libraries\STM32_USB_Device_Library\Core\inc;.\Libraries\STM32_USB_OTG_Driver\inc;.
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./src/: main.c stm32f4xx_it.c usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
  group MDK_ARM
    ./: startup_stm32f4xx.s
  group USB
    ./Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
    ./Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
    ./Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group STD
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_dma.c
  group CMSI
    ./src/: system_stm32f4xx.c
  group Joonekas
    ./: enc_input_capture.c pwm_out.c enc_input_capture.h pwm_out.h Comm.c Comm.h joonekas.c joonekas.h HW_Config.c HW_Config.h adc.c adc.h dma_uart.c dma_uart.h controller1.c controller1.h line_sens.c
